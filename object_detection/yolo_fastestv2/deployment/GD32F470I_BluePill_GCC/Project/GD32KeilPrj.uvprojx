# Keil uVision project GD32KeilPrj.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F470II GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32KeilPrj +hex
  group App
    ../App/Main/: Main.c
    ../App/LED/: LED.c
    ../App/TLILCD/: TLILCD.c
    ../App/Picture/: tjpgd.c
    ../App/IICCommon/: IICCommon.c
    ../App/Touch/: GT1151Q.c Touch.c
    ../App/GD25QXX/: GD25QXX.c
    ../App/Camera/: SCCB.c DCI.c OV2640.c Camera.c
    ../App/Beep/: Beep.c
    ../App/FontLib/: FontLib.c
  group HW
    ../HW/RCU/: RCU.c
    ../HW/Timer/: Timer.c
    ../HW/UART0/: Queue.c UART0.c
    ../HW/SDRAM/: SDRAM.c
    ../HW/SPI/: SPI.c
    ../HW/NandFlash/: FTL.c NandFlash.c
    ../HW/RTC/: RTC.c
    ../HW/UART2/: UART2.c
  group TPSW
    ../TPSW/FatFS/src/: diskio.c ff.c
    ../TPSW/FatFS/src/option/: cc936.c
  group FW
    ../FW/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group ARM
    ../ARM/System/: gd32f4xx_it.c system_gd32f4xx.c
    ../ARM/NVIC/: NVIC.c
    ../ARM/SysTick/: SysTick.c
    ../: startup_gd32f4xx.s
  group Edge_AI
    ../Edge_AI/model/: network_1.c network_1_data.c network_1_data_params.c network_2.c network_2_data.c network_2_data_params.c
    ../Edge_AI/utils/: utils.c
    ../Edge_AI/: ai_model.c
software components: CMSIS:CORE 5.5.0
